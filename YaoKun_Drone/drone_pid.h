/**
 * @file drone_pid.h
 * @brief PID 控制器类定义 
 * 
 * 希望这份详细的注释能帮助您理解 PID 的工作原理和代码实现。
 * @brief 淘宝店: 耀坤智联（提供本项目所需电子元器件套件，基础元件仅需9.9元） ； 
 * @brief 哔哩哔哩B站：耀坤智联 ； 
 * @brief 嘉立创开源硬件平台：耀坤无人机（星火计划2026开源项目）

  * PID 是比例-积分-微分控制的缩写，广泛用于无人机、机器人等需要精确控制的系统。
 * 简单理解：
 *   - 比例（P）：根据当前误差的大小产生控制量，误差越大，输出越大。能快速响应，但可能有残留误差。
 *   - 积分（I）：累积历史误差，消除比例控制无法消除的稳态误差。比如让飞机精确停在水平位置。
 *   - 微分（D）：预测误差的变化趋势，提前产生反向控制，减少超调和振荡。
 * 
 * 本类实现了标准的“位置式 PID”算法，并带有积分抗饱和（当输出限幅时，积分项自动衰减）。
 * 适用于飞控的角度环和角速率环。
 
  为什么需要 PID？ 无人机在空中会受到风、重心偏移等干扰，
  PID 控制器可以根据传感器测量的姿态误差，动态调整四个电机的转速，使飞机保持水平或按遥控指令动作。
  使用示例（在飞控代码中）：
  Pid roll_pid;                      // 创建一个横滚 PID 对象
  roll_pid.setGains(2.0f, 0.001f, 0.0f);   // 设置参数
  roll_pid.setOutputLimits(-250, 250);     // 输出范围为 -250 ~ 250
  float torque = roll_pid.update(error, dt); // 计算扭矩
 */

#pragma once   // 确保头文件只被编译一次，避免重复定义

// ============================================================
// PID 类定义
// ============================================================
class Pid {
 public:
  // ---------- 公有成员函数（外界可以调用的方法）----------

  /**
   * @brief 设置 PID 增益系数（比例、积分、微分）
   * @param kp 比例系数（P）
   * @param ki 积分系数（I）
   * @param kd 微分系数（D）
   * 
   * 这些系数需要根据实际系统整定。例如：
   *   - 如果飞机响应太慢，增大 Kp；
   *   - 如果存在静态误差（如一直偏左），增大 Ki；
   *   - 如果产生振荡，增大 Kd 或减小 Kp。
   */
  void setGains(float kp, float ki, float kd) {
    kp_ = kp;
    ki_ = ki;
    kd_ = kd;
  }

  /**
   * @brief 设置 PID 输出限幅
   * @param out_min 输出最小值（例如 -0.5 表示 -50% 扭矩）
   * @param out_max 输出最大值（例如  0.5 表示 +50% 扭矩）
   * 
   * 防止输出过大导致电机指令超出合理范围（例如油门超过 1 或低于 0）。
   */
  void setOutputLimits(float out_min, float out_max) {
    out_min_ = out_min;
    out_max_ = out_max;
  }

  /**
   * @brief 复位 PID 控制器（清零积分项和上一次误差）
   * 
   * 在解锁、切换参数或出现异常时调用，避免历史数据影响新状态。
   * 例如，飞机上锁后推油门，如果不复位积分，可能会突然产生很大的控制量。
   */
  void reset() {
    integral_ = 0.0f;      // 积分累积清零
    prev_error_ = 0.0f;    // 上一次误差清零
    has_prev_ = false;     // 标记微分项未就绪
  }

  /**
   * @brief PID 核心计算函数
   * @param error 当前误差 = 目标值 - 当前值（例如期望角度 - 实际角度）
   * @param dt    两次调用之间的时间间隔（秒），必须 > 0
   * @return 计算出的控制量（已经过输出限幅）
   * 
   * 调用方式示例（在控制循环中）：
   *   float error = target - current;
   *   float output = pid.update(error, dt);
   *   motor.set(output);
   */
  float update(float error, float dt) {
    // 如果时间间隔无效（≤0），直接返回 0，避免除以零
    if (dt <= 0.0f) {
      return 0.0f;
    }

    // ---------- 比例项（P） ----------
    // 比例输出 = Kp * 当前误差
    const float p = kp_ * error;

    // ---------- 积分项（I） ----------
    // 积分是误差随时间的累积： integral = integral + error * dt
    integral_ += error * dt;
    const float i = ki_ * integral_;   // 积分输出 = Ki * 累积误差

    // ---------- 微分项（D） ----------
    float d = 0.0f;
    if (has_prev_) {
      // 微分 = Kd * (当前误差 - 上次误差) / dt
      // 这代表了误差的变化率（斜率），能提前预测趋势
      d = kd_ * (error - prev_error_) / dt;
    }
    // 保存当前误差供下次使用
    prev_error_ = error;
    has_prev_ = true;   // 下次调用时就可以计算微分了

    // ---------- 总和并限幅 ----------
    float out = p + i + d;          // 原始 PID 输出
    out = clampf(out, out_min_, out_max_);  // 限制输出范围

    // ---------- 积分抗饱和（防积分过深）----------
    // 如果输出因为限幅被“削顶”或“削底”，说明当前积分可能过大，
    // 此时将积分项乘以 0.99，让它缓慢衰减，避免失控后积分仍累积。
    if (out == out_min_ || out == out_max_) {
      integral_ *= 0.99f;
    }

    return out;   // 返回最终控制量
  }

 private:
  // ---------- 私有成员变量（仅供类内部使用）----------
  float kp_ = 0.0f;          // 比例增益
  float ki_ = 0.0f;          // 积分增益
  float kd_ = 0.0f;          // 微分增益
  float out_min_ = -1.0f;    // 输出下限（默认 -1）
  float out_max_ = 1.0f;     // 输出上限（默认  1）
  float integral_ = 0.0f;    // 积分累积值
  float prev_error_ = 0.0f;  // 上一次的误差（用于计算微分）
  bool has_prev_ = false;    // 是否已有上一次误差（首次调用时无，跳过微分项）
};

/**
*drone_pid.h 文件实现了一个通用的 PID 控制器类，用于飞控的姿态和角速率闭环控制。
*虽然代码行数不多，但它包含了 PID 的核心功能，足以满足无人机的基本控制需求。
// ============================================================================
// 主要功能
// ============================================================================
1.设置 PID 增益 (setGains)
配置比例（Kp）、积分（Ki）、微分（Kd）系数。
2.设置输出限幅 (setOutputLimits)
限制 PID 输出范围，防止电机指令过饱和。
3.复位 (reset)
清零积分项和上一次误差，用于解锁或参数切换时避免异常输出。
4.核心计算 (update)
输入：当前误差 error 和时间间隔 dt。
输出：控制量 out = P + I + D。
积分项累积并限幅（通过积分抗饱和：当输出饱和时，积分项乘以 0.99 缓慢衰减）。
微分项使用上次误差计算，避免突变。

// ============================================================================
// 在飞控中的应用
// ============================================================================
飞控中使用了多个 PID 实例：
1.角度环 PID (g_roll_angle_pid, g_pitch_angle_pid)：
将期望角度与实际角度的误差转换为期望角速度。
2.角速率环 PID (g_roll_rate_pid, g_pitch_rate_pid, g_yaw_rate_pid)：
将期望角速度与实际角速度的误差转换为电机扭矩指令。
这些 PID 对象在 control.ino 中定义，并在 controlStep() 中调用 update() 计算控制量。

// ============================================================================
// 为什么代码这么少？
// ============================================================================
因为：
没有硬件依赖，纯数学计算。
没有复杂的滤波或自适应逻辑（留给上层调用者处理）。
飞控不需要高级 PID 变体（如增量式、积分分离等），简单的位置式 PID 配合抗饱和已足够。
因此，这个简洁的实现既满足了性能要求，又保持了代码可读性

// ============================================================================
// 补充说明
// ============================================================================
clampf 函数：这个类里用到了 clampf，它是在 drone_types.h 中定义的全局内联函数，
用于将数值限制在指定范围。例如 clampf(1.5, 0, 1) 会返回 1。

 */